CMDLINE_ROOT_PARTITION = "/dev/sda2"
CMDLINE:append = " video=DSI-1:400x1280e,rotate=90"
